require gcc-linaro/gcc-cross_${PV}.bb
require gcc/gcc-cross-initial.inc
