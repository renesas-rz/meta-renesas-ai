FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	file://0001-ragged-set-of-patches-to-allow-cross-compile.patch \
"

