require gcc-linaro/gcc-${PV}.inc
require gcc/gcc-cross-canadian.inc
