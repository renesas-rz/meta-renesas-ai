SRC_URI_remove = " gitsm://github.com/renesas-rcar/gst-plugins-bad.git;branch=RCAR-GEN3e/1.16.3;name=base"
SRC_URI_append = " gitsm://github.com/renesas-rcar/gst-plugins-bad.git;protocol=https;branch=RCAR-GEN3e/1.16.3;name=base"
