LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI[md5sum] = "38b0fb11bb22b676338898ed87ec19e7"
SRC_URI[sha256sum] = "334429059cf82e222ca8a9d9dbbd26f8e1eb308613463c2b8655dd4201b127ec"

include bazel-native.inc
