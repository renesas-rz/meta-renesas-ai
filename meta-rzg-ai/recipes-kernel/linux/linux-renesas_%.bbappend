FILESEXTRAPATHS_prepend := "${THISDIR}/linux-renesas:"

SRC_URI_append = "file://swap.cfg"
