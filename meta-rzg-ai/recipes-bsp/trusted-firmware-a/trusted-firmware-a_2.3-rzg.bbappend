do_compile[depends] += "u-boot:do_deploy"
