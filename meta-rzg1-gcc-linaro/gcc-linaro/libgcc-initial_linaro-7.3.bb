require gcc-linaro/gcc-${PV}.inc
require gcc/libgcc-initial.inc
