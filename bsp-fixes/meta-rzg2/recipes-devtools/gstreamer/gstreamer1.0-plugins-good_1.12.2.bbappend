SRC_URI_remove = " git://github.com/renesas-rcar/gst-plugins-good.git;branch=RCAR-GEN3/1.12.2;name=base"
SRC_URI_append = " git://github.com/renesas-rcar/gst-plugins-good.git;protocol=https;branch=RCAR-GEN3/1.12.2;name=base"
