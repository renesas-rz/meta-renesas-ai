# This recipe comes from
# https://github.com/openembedded/meta-openembedded/blob/master/meta-python/recipes-devtools/python/python-six_1.11.0.bb
inherit pypi setuptools

require python-six.inc
