def replaceChar(s,old,new):
    return s.replace(old, new)
