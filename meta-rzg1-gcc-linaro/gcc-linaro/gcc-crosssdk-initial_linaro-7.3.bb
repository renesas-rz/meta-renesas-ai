require gcc-linaro/gcc-cross-initial_${PV}.bb
require gcc/gcc-crosssdk-initial.inc
