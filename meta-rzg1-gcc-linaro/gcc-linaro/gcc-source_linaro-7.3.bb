require gcc-linaro/gcc-${PV}.inc
require gcc/gcc-source.inc

EXCLUDE_FROM_WORLD = "1"
